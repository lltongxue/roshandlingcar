Commit message: 修改car_model_t4的urdf模型参数，防止抖动

File: src/car_model_t4/urdf/car_model_t4.urdf (robot description, URDF)
Before this commit: robot car_model_t4, 5 links, 4 joints
Links:
- link right_wheel: mass 0.013453 -> 0.013351
